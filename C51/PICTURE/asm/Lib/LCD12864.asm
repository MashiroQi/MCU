LCD12864  SEGMENT  CODE
RSEG  LCD12864

EXTRN CODE (DELAY)
	
PUBLIC WCMD,WDAT,INIT


RS BIT P2.3
RW BIT P2.4
EN BIT P2.5

;写入命令为A中数据
WCMD: 
	CLR RS
	CLR RW
	CLR EN
	MOV P0,A
	SETB EN
	CLR	EN
	RET

;写入数据为A数据
WDAT:
	SETB RS
	CLR RW
	CLR EN
	MOV P0,A
	SETB EN
	CLR EN
	RET

;初始化
INIT:
	MOV A,#34H
	CALL WCMD 
	MOV A,#50
	CALL DELAY
	MOV A,#30H
	CALL WCMD
	MOV A,#50
	CALL DELAY
	MOV A,#0CH
	CALL WCMD 
	MOV A,#50
	CALL DELAY
	MOV A,#01H
	CALL WCMD 
	MOV A,#50
	CALL DELAY
	
	MOV A,#36H
	CALL WCMD 
	MOV A,#50
	CALL DELAY
	RET
	

END