# Keil uVision project PICTURE.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: PICTURE +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Main;.\Lib
  asm include: .\Main;.\Lib
  group Main
    ./Main/: main.asm
  group Lib
    ./Lib/: LCD12864.asm UART.asm PUB.asm
