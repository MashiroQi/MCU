# Keil uVision project badapple.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: badapple +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\Library
  group User
    ./User/: main.c
  group Library
    ./Library/: LCD12864.h public.h serial.h
